# Keil uVision project PWR2_inv.uvproj, settings and files
target PWR_inv (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PWR2_inv +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS;..\CMSIS\DeviceSupport\MDR32F9Qx\inc;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\MDR32F9Qx\startup\arm;..\MDR32F9Qx_SPL;..\Source
  memory RVCT4: ROM 0x8001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../CMSIS/: MDR32F9Qx_config.h
    ../CMSIS/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c
    ../CMSIS/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ../CMSIS/CoreSupport/: core_cm3.h
  group StartUp
    ../StartUp/: startup_MDR32F9x.s
  group Source
    ../Source/: main.c CNTL_3P3Z.c PID.c sogi.c pll.c
  group SPL
    ../MDR32F9Qx_SPL/: MDR32F9Qx_can.c MDR32F9Qx_can.h MDR32F9Qx_port.c MDR32F9Qx_port.h MDR32F9Qx_rst_clk.c MDR32F9Qx_rst_clk.h MDR32F9Qx_timer.c MDR32F9Qx_timer.h MDR32F9Qx_adc.c MDR32F9Qx_adc.h MDR32F9Qx_dac.c
